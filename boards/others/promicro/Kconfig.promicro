## boards/others/promicro/Kconfig.promicro
```kconfig
# Copyright (c) 2024 Nordic Semiconductor ASA
# SPDX-License-Identifier: Apache-2.0

config BOARD_PROMICRO
	select SOC_NRF52840_QIAA
```
